# Keil uVision project Project.uvprojx, settings and files
target ZFWL_V2.1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F105RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\USER;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\USER\SD_Card;..\USER\FATFS_V0.08A\src;..\Libraries\STM32_USB_HOST_Driver\inc;..\Libraries\STM32_USB_HOST_Library\Core\inc;..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\USER\MSC;..\USER\GLCD;..\Libraries\STM32_USB_HOST_Library\Class\HID\inc;..\..\DGUS;..\..\Driver;..\..\MidLevel;..\..\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../StartUp/: startup_stm32f10x_cl.s
  group User_main
    ../../USER/: main.c stm32f10x_it.c
  group DGUS
    ../../DGUS/: DGUS.C StartUp.c FreeProgramme.c ManulOperate.c IOControl.c SystemSetting.c AlarmHistory.c IOCommand.c
  group Driver
    ../../Driver/: 24Cxx.c Delay.c I2CInt.c key.c PlatformInit.c Usart.c
    ../../USER/: Tim_Usart_IRQ.c
  group MidLevel
    ../../MidLevel/: Parameter.c USart1_Robot.c
  group User
    ../USER/MSC/: usbh_usr.h usb_bsp.c usbh_usr.c
    ../USER/: stm32f10x_conf.h
  group USB_Core
    ../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group USB_MSC
    ../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
  group USB_Driver
    ../Libraries/STM32_USB_HOST_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group FATFS V0.08A
    ../USER/FATFS_V0.08A/src/: ff.c diskio.c ffconf.h
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../USER/: system_stm32f10x.c
  group README
    ../../: README.TXT
