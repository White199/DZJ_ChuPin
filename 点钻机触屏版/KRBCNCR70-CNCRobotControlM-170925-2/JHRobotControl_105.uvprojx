# Keil uVision project JHRobotControl_105.uvprojx, settings and files
target JHRobotControl (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: JHRobotControl_105 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\Driver;.\User;.\StatusControl;.\FWlib\inc;.\FWlib\src;.\CANopen;.\MidLevel
  asm include: .\Driver;.\MidLevel;.\StatusControl;.\User
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group FWlib
    ./FWlib/src/: stm32f10x_usart.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_rtc.c stm32f10x_exti.c stm32f10x_sdio.c stm32f10x_wwdg.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_fsmc.c stm32f10x_iwdg.c
  group StartUp
    ./StartUp/: cortexm3_macro.s stm32f10x_vector.s
  group User
    ./User/: main.c stm32f10x_it.c TIM6_USART1_IRQ.c
  group Driver
    ./Driver/: Delay.c in.c out.c platform_init.c PulseInit.c spi.c w25qxx.c
  group StatusControl
    ./StatusControl/: Auto.c Manual.c StatusControl.c SignalWatch.c Error.c BackToOrigin.c Auto_2.c
  group MidLevel
    ./MidLevel/: SpeedControl.c Usart.c Parameter.c ActionOperate.c SpeedControl_CAN.c Homing.c
  group CANopen
    ./CANopen/: CANopen.c EMCY.c NMT.c PDO.c SDO.c Sync.c
  group README
    ./: readme.txt
